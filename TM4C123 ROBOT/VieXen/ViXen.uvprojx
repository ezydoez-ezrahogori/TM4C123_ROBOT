# Keil uVision project ViXen.uvprojx, settings and files
target TM4123 (6190000::V6.19::ARMCLANG)
  device: TM4C1294KCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ViXen
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ./: main.c
  group Head
    ./: head.c head.s head.h
  group Docs
    ./: pin_connection.txt
  group Timer
    ./: delay.c
  group Light
    ./: light.h light.s
  group Neck
    ./: neck.c neck.h
  group Limb
    ./: limb.c limb.h limb.S
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.0.0, Graphics:CORE 6.24.0
